# Disable thumb
ARM_INSTRUCTION_SET_armv7a = "arm"

require rpb-initramfs-image.bb

IMAGE_INSTALL += "make stress-ng"

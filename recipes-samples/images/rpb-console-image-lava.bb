require rpb-console-image.bb

CORE_IMAGE_BASE_INSTALL += " \
    packagegroup-rpb-tests \
    "

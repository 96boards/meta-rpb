FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://enable-setsid-tty.cfg"
SRC_URI += "file://enable-install.cfg"

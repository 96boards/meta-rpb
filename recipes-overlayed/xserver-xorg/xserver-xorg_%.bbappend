# enable XvFB for gst-validate

PACKAGECONFIG:append = " xvfb"
